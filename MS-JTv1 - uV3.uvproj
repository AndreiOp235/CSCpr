# Keil uVision project MS-JTv1 - uV3.uvproj, settings and files
target MSv1 - uV3 (MCS-51)
  device: C8051F040 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: MSv1
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BIG8051\Include
  group Drivers
    ./BIG8051/Drivers/: timer.c uart1.c lcd.c keyb.c osc.c port.c uart0.c wdt.c
  group Application
    ./: MS-JT.c TxMesajV1.c RxMesajV1.c UserIO.c
